## package/wilc-firmware/Config.in
```kconfig
config BR2_PACKAGE_WILC_FIRMWARE
	bool "WILC-firmware"
	help
	  Firmware for the Atmel Wifi devices supported by the WILC1000
	  kernel driver.
```
